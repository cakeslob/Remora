# Keil uVision project firmware.uvprojx, settings and files
target firmware (6070000::V6.7::.\ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: firmware
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: TRANSACTION_QUEUE_SIZE_SPI=2 TARGET_LIKE_CORTEX_M4 ARM_MATH_CM4 DEVICE_RESET_REASON=1 DEVICE_I2C_ASYNCH=1 TOOLCHAIN_ARM_STD MULADDC_CANNOT_USE_R7 USE_HAL_DRIVER MBED_MINIMAL_PRINTF DEVICE_INTERRUPTIN=1 TARGET_LIKE_MBED MBED_DEBUG TARGET_MCU_STM32F446xE __MBED__=1 TARGET_CORTEX_M TARGET_FF_ARDUINO_UNO DEVICE_SERIAL_FC=1 DEVICE_ANALOGIN=1 __ASSERT_MSG DEVICE_ANALOGOUT=1 DEVICE_PORTINOUT=1 TARGET_MCU_STM32F4 DEVICE_SPISLAVE=1 TOOLCHAIN_ARM __CMSIS_RTOS MBED_RAM_SIZE=0x20000 DEVICE_SERIAL_ASYNCH=1 TOOLCHAIN_ARMC6 __CORTEX_M4 __FPU_PRESENT=1 MBED_RAM_START=0x20000000 DEVICE_SPI=1 MBED_ROM_SIZE=0x80000 DEVICE_FLASH=1 __MBED_CMSIS_RTOS_CM MBED_TRAP_ERRORS_ENABLED=1 DEVICE_I2C=1 TARGET_CORTEX DEVICE_I2CSLAVE=1 TARGET_STM32F446xE TARGET_M4 TARGET_NAME=NUCLEO_F446RE COMPONENT_FLASHIAP=1 DEVICE_STDIO_MESSAGES=1 USE_FULL_LL_DRIVER TARGET_RELEASE MBED_BUILD_TIMESTAMP=1719367641.758613 TARGET_STM32F4 DEVICE_SLEEP=1 DEVICE_PORTIN=1 DEVICE_WATCHDOG=1 TARGET_NUCLEO_F446RE DEVICE_SPI_ASYNCH=1 DEVICE_RTC=1 MBED_ROM_START=0x8000000 TARGET_RTOS_M4_M7 TARGET_MCU_STM32 DEVICE_PORTOUT=1 DEVICE_PWMOUT=1 TARGET_STM DEVICE_MPU=1 DEVICE_SERIAL=1 DEVICE_CAN=1 STM32F446xx DEVICE_LPTICKER=1 DEVICE_USTICKER=1
  c misc: -fshort-wchar -mcpu=cortex-m4 -mfloat-abi=hard -g -fno-c++-static-destructors -Wno-deprecated-register --target=arm-arm-none-eabi -Wno-armcc-pragma-push-pop -fno-exceptions -fno-rtti -Wno-reserved-user-defined-literal -c -Wno-armcc-pragma-anon-unions -mthumb -mfpu=fpv4-sp-d16 -fshort-enums -fdata-sections -include mbed_config.h
  c include: .;SoftwareSerial;TARGET_NUCLEO_F446RE;TARGET_STM32F4;TARGET_STM32F4/drivers;TARGET_STM32F4/drivers/SDIO;TARGET_STM32F4/drivers/comms;TARGET_STM32F4/drivers/qei;TARGET_STM32F4/thread;TARGET_STM32F446xE;TARGET_STM32F446xE/drivers;TARGET_STM32F446xE/drivers/pin;TMCStepper;drivers;drivers/softPwm;lib;lib/ArduinoJson6;lib/ArduinoJson6/ArduinoJson;lib/ArduinoJson6/ArduinoJson/Array;lib/ArduinoJson6/ArduinoJson/Collection;lib/ArduinoJson6/ArduinoJson/Deserialization;lib/ArduinoJson6/ArduinoJson/Document;lib/ArduinoJson6/ArduinoJson/Json;lib/ArduinoJson6/ArduinoJson/Memory;lib/ArduinoJson6/ArduinoJson/Misc;lib/ArduinoJson6/ArduinoJson/MsgPack;lib/ArduinoJson6/ArduinoJson/Numbers;lib/ArduinoJson6/ArduinoJson/Object;lib/ArduinoJson6/ArduinoJson/Operators;lib/ArduinoJson6/ArduinoJson/Polyfills;lib/ArduinoJson6/ArduinoJson/Polyfills/gsl;lib/ArduinoJson6/ArduinoJson/Polyfills/mpl;lib/ArduinoJson6/ArduinoJson/Polyfills/type_traits;lib/ArduinoJson6/ArduinoJson/Serialization;lib/ArduinoJson6/ArduinoJson/StringStorage;lib/ArduinoJson6/ArduinoJson/Strings;lib/ArduinoJson6/ArduinoJson/Variant;mbed-os;mbed-os/cmsis;mbed-os/cmsis/CMSIS_5;mbed-os/cmsis/CMSIS_5/CMSIS;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2;mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M;mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include;mbed-os/cmsis/device;mbed-os/cmsis/device/RTE;mbed-os/cmsis/device/RTE/include;mbed-os/cmsis/device/rtos;mbed-os/connectivity;mbed-os/connectivity/cellular;mbed-os/connectivity/drivers;mbed-os/connectivity/drivers/802.15.4_RF;mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver;mbed-os/connectivity/drivers/cellular;mbed-os/connectivity/drivers/cellular/Altair;mbed-os/connectivity/drivers/cellular/Altair/ALT1250;mbed-os/connectivity/drivers/cellular/Altair/ALT1250/PPP;mbed-os/connectivity/drivers/cellular/GEMALTO;mbed-os/connectivity/drivers/cellular/GEMALTO/CINTERION;mbed-os/connectivity/drivers/cellular/GENERIC;mbed-os/connectivity/drivers/cellular/GENERIC/GENERIC_AT3GPP;mbed-os/connectivity/drivers/cellular/MultiTech;mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano;mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano/PPP;mbed-os/connectivity/drivers/cellular/QUECTEL;mbed-os/connectivity/drivers/cellular/QUECTEL/BC95;mbed-os/connectivity/drivers/cellular/QUECTEL/BG96;mbed-os/connectivity/drivers/cellular/QUECTEL/EC2X;mbed-os/connectivity/drivers/cellular/QUECTEL/M26;mbed-os/connectivity/drivers/cellular/QUECTEL/UG96;mbed-os/connectivity/drivers/cellular/RiotMicro;mbed-os/connectivity/drivers/cellular/RiotMicro/AT;mbed-os/connectivity/drivers/cellular/TELIT;mbed-os/connectivity/drivers/cellular/TELIT/HE910;mbed-os/connectivity/drivers/cellular/TELIT/ME310;mbed-os/connectivity/drivers/cellular/TELIT/ME910;mbed-os/connectivity/drivers/cellular/UBLOX;mbed-os/connectivity/drivers/cellular/UBLOX/AT;mbed-os/connectivity/drivers/cellular/UBLOX/N2XX;mbed-os/connectivity/drivers/cellular/UBLOX/PPP;mbed-os/connectivity/drivers/emac/TARGET_STM;mbed-os/connectivity/drivers/mbedtls/TARGET_STM;mbed-os/connectivity/drivers/nfc;mbed-os/connectivity/drivers/nfc/PN512;mbed-os/connectivity/drivers/wifi;mbed-os/connectivity/drivers/wifi/esp8266-driver;mbed-os/connectivity/libraries;mbed-os/connectivity/libraries/mbed-coap;mbed-os/connectivity/libraries/nanostack-libservice;mbed-os/connectivity/libraries/ppp;mbed-os/connectivity/lorawan;mbed-os/connectivity/lwipstack;mbed-os/connectivity/mbedtls;mbed-os/connectivity/nanostack;mbed-os/connectivity/netsocket;mbed-os/connectivity/nfc;mbed-os/drivers;mbed-os/drivers/device_key;mbed-os/drivers/include;mbed-os/drivers/include/drivers;mbed-os/drivers/include/drivers/interfaces;mbed-os/drivers/usb;mbed-os/events;mbed-os/features;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/mbed-client-cli;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/utest;mbed-os/hal;mbed-os/hal/include;mbed-os/hal/include/hal;mbed-os/hal/usb;mbed-os/hal/usb/include;mbed-os/hal/usb/include/usb;mbed-os/platform;mbed-os/platform/cxxsupport;mbed-os/platform/include;mbed-os/platform/include/platform;mbed-os/platform/include/platform/internal;mbed-os/platform/mbed-trace;mbed-os/platform/mbed-trace/include;mbed-os/platform/mbed-trace/include/mbed-trace;mbed-os/platform/randlib;mbed-os/platform/source;mbed-os/platform/source/minimal-printf;mbed-os/rtos;mbed-os/rtos/include;mbed-os/rtos/include/rtos;mbed-os/rtos/include/rtos/internal;mbed-os/rtos/source;mbed-os/storage;mbed-os/storage/blockdevice;mbed-os/storage/blockdevice/COMPONENT_FLASHIAP;mbed-os/storage/blockdevice/include;mbed-os/storage/blockdevice/include/blockdevice;mbed-os/storage/blockdevice/include/blockdevice/internal;mbed-os/storage/filesystem;mbed-os/storage/kvstore;mbed-os/targets/TARGET_STM;mbed-os/targets/TARGET_STM/TARGET_STM32F4;mbed-os/targets/TARGET_STM/TARGET_STM32F4/STM32Cube_FW;mbed-os/targets/TARGET_STM/TARGET_STM32F4/STM32Cube_FW/CMSIS;mbed-os/targets/TARGET_STM/TARGET_STM32F4/STM32Cube_FW/STM32F4xx_HAL_Driver;mbed-os/targets/TARGET_STM/TARGET_STM32F4/STM32Cube_FW/STM32F4xx_HAL_Driver/Legacy;mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE;mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446RE;modules;modules/blink;modules/debug;modules/digipot;modules/digitalPin;modules/eStop;modules/encoder;modules/motorPower;modules/pwm;modules/qei;modules/rcservo;modules/resetPin;modules/stepgen;modules/switch;modules/temperature;modules/tmc;sensors;sensors/thermistor;thread;c:/Users/Lenovo/Documents/REMORA_REPOS/Remora-nucleo_static_H723/New folder/mbed-os
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DARM_MATH_CM4,-DUSE_FULL_LL_DRIVER,-DSTM32F446xx,-D__FPU_PRESENT=1,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DUSE_HAL_DRIVER,-D__CORTEX_M4,-DTRANSACTION_QUEUE_SIZE_SPI=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TOOLCHAIN_ARM/stm32f446xe.sct
  link misc: --show_full_path --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --verbose --keep=os_cb_sections --predefine="-DMBED_RAM_START=0x20000000" --legacyalign --remove --predefine="-DMBED_RAM_SIZE=0x20000" --predefine="-DMBED_ROM_SIZE=0x80000" --any_contingency --cpu=Cortex-M4 --predefine="-DXIP_ENABLE=0"
  group drivers
    ./drivers/softPwm/: softPwm.cpp softPwm.h
  group firmware
    ./: configuration.h extern.h main.cpp remora.h
    ./: mbed_config.h
  group lib
    ./lib/ArduinoJson6/ArduinoJson/Polyfills/: alias_cast.hpp assert.hpp attributes.hpp ctype.hpp limits.hpp math.hpp type_traits.hpp utility.hpp
    ./lib/ArduinoJson6/ArduinoJson/Memory/: Alignment.hpp MemoryPool.hpp StringBuilder.hpp StringSlot.hpp
    ./lib/ArduinoJson6/: ArduinoJson.h ArduinoJson.hpp
    ./lib/ArduinoJson6/ArduinoJson/Deserialization/: ArduinoStreamReader.hpp CharPointerReader.hpp DeserializationError.hpp deserialize.hpp FlashStringReader.hpp IteratorReader.hpp NestingLimit.hpp StdStreamReader.hpp
    ./lib/ArduinoJson6/ArduinoJson/Strings/: ArduinoStringAdapter.hpp ConstRamStringAdapter.hpp FlashStringAdapter.hpp RamStringAdapter.hpp SizedFlashStringAdapter.hpp SizedRamStringAdapter.hpp StlStringAdapter.hpp String.hpp StringAdapters.hpp
    ./lib/ArduinoJson6/ArduinoJson/Array/: ArrayFunctions.hpp ArrayImpl.hpp ArrayIterator.hpp ArrayRef.hpp ArrayShortcuts.hpp ElementProxy.hpp Utilities.hpp
    ./lib/ArduinoJson6/ArduinoJson/Document/: BasicJsonDocument.hpp DynamicJsonDocument.hpp JsonDocument.hpp StaticJsonDocument.hpp
    ./lib/ArduinoJson6/ArduinoJson/Collection/: CollectionData.hpp CollectionImpl.hpp
    ./lib/ArduinoJson6/ArduinoJson/: compatibility.hpp Configuration.hpp Namespace.hpp version.hpp
    ./lib/ArduinoJson6/ArduinoJson/Polyfills/type_traits/: conditional.hpp enable_if.hpp integral_constant.hpp is_array.hpp is_base_of.hpp is_const.hpp is_floating_point.hpp is_integral.hpp is_same.hpp is_signed.hpp is_unsigned.hpp make_unsigned.hpp remove_const.hpp remove_reference.hpp type_identity.hpp
    ./lib/ArduinoJson6/ArduinoJson/Numbers/: convertNumber.hpp Float.hpp FloatParts.hpp FloatTraits.hpp Integer.hpp parseFloat.hpp parseInteger.hpp parseNumber.hpp
    ./lib/ArduinoJson6/ArduinoJson/Serialization/: DummyWriter.hpp DynamicStringWriter.hpp measure.hpp serialize.hpp StaticStringWriter.hpp StreamWriter.hpp
    ./lib/ArduinoJson6/ArduinoJson/MsgPack/: endianess.hpp ieee754.hpp MsgPackDeserializer.hpp MsgPackSerializer.hpp
    ./lib/ArduinoJson6/ArduinoJson/Json/: EscapeSequence.hpp JsonDeserializer.hpp JsonSerializer.hpp PrettyJsonSerializer.hpp TextFormatter.hpp Utf8.hpp
    ./lib/ArduinoJson6/ArduinoJson/Polyfills/mpl/: max.hpp
    ./lib/ArduinoJson6/ArduinoJson/Object/: MemberProxy.hpp ObjectFunctions.hpp ObjectImpl.hpp ObjectIterator.hpp ObjectRef.hpp ObjectShortcuts.hpp Pair.hpp
    ./lib/ArduinoJson6/ArduinoJson/Polyfills/gsl/: not_null.hpp
    ./lib/ArduinoJson6/ArduinoJson/Misc/: SerializedValue.hpp Visitable.hpp
    ./lib/ArduinoJson6/ArduinoJson/Variant/: SlotFunctions.hpp VariantAs.hpp VariantAsImpl.hpp VariantContent.hpp VariantData.hpp VariantFunctions.hpp VariantImpl.hpp VariantRef.hpp VariantSlot.hpp VariantTo.hpp
    ./lib/ArduinoJson6/ArduinoJson/StringStorage/: StringCopier.hpp StringMover.hpp StringStorage.hpp
    ./lib/ArduinoJson6/ArduinoJson/Operators/: VariantCasts.hpp VariantComparisons.hpp VariantOperators.hpp VariantOr.hpp VariantShortcuts.hpp
  group mbed-os
    ./mbed-os/drivers/source/: AnalogIn.cpp AnalogOut.cpp BufferedSerial.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp DigitalIn.cpp DigitalInOut.cpp DigitalOut.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp MbedCRC.cpp OSPI.cpp PortIn.cpp PortInOut.cpp PortOut.cpp PwmOut.cpp QSPI.cpp ResetReason.cpp SerialBase.cpp SerialWireOutput.cpp SPI.cpp SPISlave.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp UnbufferedSerial.cpp Watchdog.cpp
    ./mbed-os/drivers/include/drivers/: AnalogIn.h AnalogOut.h BufferedSerial.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h FlashIAP.h HighResClock.h I2C.h I2CSlave.h InterruptIn.h LowPowerClock.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h OSPI.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawCAN.h RealTimeClock.h ResetReason.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h Ticker.h TickerDataClock.h Timeout.h Timer.h TimerEvent.h UnbufferedSerial.h Watchdog.h
    ./mbed-os/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c device.h gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_overrides.c i2c_api.c lp_ticker.c lp_ticker_defines.h mbed_crc_api.c mbed_overrides.c mbed_rtx.h nvic_addr.h ospi_api.c PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c qspi_api.c reset_reason.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_i2c_api.h stm_spi_api.c trng_api.c us_ticker.c us_ticker_defines.h USBPhy_STM32.cpp USBPhyHw.h watchdog_api.c
    ./mbed-os/hal/include/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h ospi_api.h pinmap.h PinNameAliases.h port_api.h pwmout_api.h qspi_api.h reset_reason_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h static_pinmap.h ticker_api.h trng_api.h us_ticker_api.h watchdog_api.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/: analogin_device.c analogout_device.c can_device.h cmsis.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.h objects.h PeripheralNames.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h us_ticker_data.h
    ./mbed-os/platform/source/: ATCmdParser.cpp CriticalSectionLock.cpp CThunkBase.cpp DeepSleepLock.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c mbed_assert.c mbed_atomic_impl.c mbed_board.c mbed_crash_data_offsets.h mbed_critical.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mem_trace.cpp mbed_mktime.c mbed_mpu_mgmt.c mbed_os_timer.cpp mbed_poll.cpp mbed_power_mgmt.c mbed_retarget.cpp mbed_rtc_time.cpp mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_thread.cpp mbed_wait_api_no_rtos.c newlib_nano_malloc_workaround.c Stream.cpp SysTimer.cpp
    ./mbed-os/platform/include/platform/: ATCmdParser.h Callback.h CircularBuffer.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_atomic.h mbed_chrono.h mbed_critical.h mbed_debug.h mbed_enum_flags.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_stats.h mbed_thread.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h SharedPtr.h SingletonPtr.h Span.h Stream.h Transaction.h
    ./mbed-os/storage/blockdevice/include/blockdevice/: BlockDevice.h BufferedBlockDevice.h ChainingBlockDevice.h ExhaustibleBlockDevice.h FlashSimBlockDevice.h HeapBlockDevice.h MBRBlockDevice.h ObservingBlockDevice.h ProfilingBlockDevice.h ReadOnlyBlockDevice.h SlicingBlockDevice.h
    ./mbed-os/storage/blockdevice/source/: BufferedBlockDevice.cpp ChainingBlockDevice.cpp ExhaustibleBlockDevice.cpp FlashSimBlockDevice.cpp HeapBlockDevice.cpp MBRBlockDevice.cpp ObservingBlockDevice.cpp ProfilingBlockDevice.cpp ReadOnlyBlockDevice.cpp SFDP.cpp SlicingBlockDevice.cpp
    ./mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/: cmsis_nvic.h flash_data.h system_clock.c
    ./mbed-os/rtos/source/: ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp rtos_handlers.h rtos_idle.h Semaphore.cpp ThisThread.cpp Thread.cpp
    ./mbed-os/rtos/include/rtos/: ConditionVariable.h EventFlags.h Kernel.h Mail.h mbed_rtos_types.h MemoryPool.h Mutex.h Queue.h rtos.h Semaphore.h ThisThread.h Thread.h
    ./mbed-os/platform/include/platform/internal/: CThunkBase.h mbed_atomic_impl.h mbed_error_hist.h mbed_fault_handler.h mbed_os_timer.h SysTimer.h
    ./mbed-os/platform/source/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    ./mbed-os/drivers/include/drivers/interfaces/: InterfaceCAN.h InterfaceDigitalIn.h InterfaceDigitalInOut.h InterfaceDigitalOut.h
    ./mbed-os/hal/source/: LowPowerTickerWrapper.cpp mbed_compat.c mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_gpio_irq.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_pinmap_common.c mbed_pinmap_default.cpp mbed_ticker_api.c mbed_us_ticker_api.c static_pinmap.cpp
    ./mbed-os/: mbed.h
    ./mbed-os/cmsis/device/: mbed_cmsis_conf.h
    ./mbed-os/platform/source/TARGET_CORTEX_M/: mbed_fault_handler.c
    ./mbed-os/features/frameworks/mbed-greentea-io/: mbed_io.cpp
    ./mbed-os/hal/source/mpu/: mbed_mpu_v7m.c mbed_mpu_v8m.c
    ./mbed-os/platform/source/minimal-printf/: mbed_printf_armlink_overrides.c mbed_printf_implementation.c mbed_printf_implementation.h mbed_printf_wrapper.c
    ./mbed-os/rtos/include/rtos/internal/: mbed_rtos1_types.h mbed_rtos_storage.h
    ./mbed-os/platform/mbed-trace/source/: mbed_trace.c
    ./mbed-os/platform/mbed-trace/include/mbed-trace/: mbed_trace.h ns_trace.h
    ./mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Source/: mbed_tz_context.c
    ./mbed-os/hal/usb/source/: mbed_usb_phy.cpp
    ./mbed-os/platform/cxxsupport/: mstd_mutex.cpp
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446RE/: PeripheralPins.c PinNames.h
    ./mbed-os/cmsis/device/RTE/include/: RTE_Components.h
    ./mbed-os/storage/blockdevice/include/blockdevice/internal/: SFDP.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TOOLCHAIN_ARM/: startup_stm32f446xx.S
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/STM32Cube_FW/STM32F4xx_HAL_Driver/Legacy/: stm32_hal_legacy.h stm32f4xx_hal_can_legacy.c stm32f4xx_hal_can_legacy.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/STM32Cube_FW/CMSIS/: stm32f401xc.h stm32f401xe.h stm32f405xx.h stm32f407xx.h stm32f410cx.h stm32f410rx.h stm32f410tx.h stm32f411xe.h stm32f412cx.h stm32f412rx.h stm32f412vx.h stm32f412zx.h stm32f413xx.h stm32f415xx.h stm32f417xx.h stm32f423xx.h stm32f427xx.h stm32f429xx.h stm32f437xx.h stm32f439xx.h stm32f446xx.h stm32f469xx.h stm32f479xx.h stm32f4xx.h system_stm32f4xx.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/STM32Cube_FW/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal.h stm32f4xx_hal_adc.c stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.c stm32f4xx_hal_can.h stm32f4xx_hal_cec.c stm32f4xx_hal_cec.h stm32f4xx_hal_cortex.c stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.c stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.c stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.c stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.c stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.c stm32f4xx_hal_eth.h stm32f4xx_hal_exti.c stm32f4xx_hal_exti.h stm32f4xx_hal_flash.c stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus.h stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_fmpsmbus_ex.h stm32f4xx_hal_gpio.c stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.c stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.c stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.c stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.c stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.c stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_mmc.c stm32f4xx_hal_mmc.h stm32f4xx_hal_nand.c stm32f4xx_hal_nand.h stm32f4xx_hal_nor.c stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.c stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.c stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.c stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.c stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.c stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.c stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.c stm32f4xx_hal_smartcard.h stm32f4xx_hal_smbus.c stm32f4xx_hal_smbus.h stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.c stm32f4xx_hal_spi.h stm32f4xx_hal_sram.c stm32f4xx_hal_sram.h stm32f4xx_hal_tim.c stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.c stm32f4xx_hal_uart.h stm32f4xx_hal_usart.c stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.c stm32f4xx_hal_wwdg.h stm32f4xx_ll_adc.c stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.c stm32f4xx_ll_crc.h stm32f4xx_ll_dac.c stm32f4xx_ll_dac.h stm32f4xx_ll_dma.c stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.c stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.c stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.c stm32f4xx_ll_fmc.h stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fmpi2c.h stm32f4xx_ll_fsmc.c stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.c stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.c stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.c stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.c stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.c stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.c stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.c stm32f4xx_ll_rtc.h stm32f4xx_ll_sdmmc.c stm32f4xx_ll_sdmmc.h stm32f4xx_ll_spi.c stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.c stm32f4xx_ll_tim.h stm32f4xx_ll_usart.c stm32f4xx_ll_usart.h stm32f4xx_ll_usb.c stm32f4xx_ll_usb.h stm32f4xx_ll_utils.c stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/STM32Cube_FW/: stm32f4xx_hal_conf.h system_stm32f4xx.c
    ./mbed-os/hal/usb/include/usb/: usb_phy_api.h USBPhy.h USBPhyEvents.h USBPhyTypes.h
  group modules
    ./modules/blink/: blink.cpp blink.h
    ./modules/debug/: debug.cpp debug.h
    ./modules/digipot/: DigipotBase.h mcp4451.cpp mcp4451.h
    ./modules/digitalPin/: digitalPin.cpp digitalPin.h
    ./modules/encoder/: encoder.cpp encoder.h
    ./modules/eStop/: eStop.cpp eStop.h
    ./modules/pwm/: hardwarePwm.cpp hardwarePwm.h pwm.cpp pwm.h
    ./modules/: module.cpp module.h
    ./modules/motorPower/: motorPower.cpp motorPower.h
    ./modules/qei/: qei.cpp qei.h
    ./modules/rcservo/: rcservo.cpp rcservo.h
    ./modules/resetPin/: resetPin.cpp resetPin.h
    ./modules/stepgen/: stepgen.cpp stepgen.h
    ./modules/switch/: switch.cpp switch.h
    ./modules/temperature/: temperature.cpp temperature.h
    ./modules/tmc/: tmc.h tmc2208.cpp tmc2209.cpp
  group sensors
    ./sensors/: tempSensor.h
    ./sensors/thermistor/: thermistor.cpp thermistor.h
  group SoftwareSerial
    ./SoftwareSerial/: SoftwareSerial.cpp SoftwareSerial.h
  group TARGET_NUCLEO_F446RE
    ./TARGET_NUCLEO_F446RE/: board_config.h
  group TARGET_STM32F4
    ./TARGET_STM32F4/thread/: createThreads.h interrupt.cpp interrupt.h irqHandlers.h pruThread.cpp pruThread.h timer.cpp timer.h
    ./TARGET_STM32F4/drivers/qei/: qeiDriver.cpp qeiDriver.h
    ./TARGET_STM32F4/drivers/comms/: RemoraComms.cpp RemoraComms.h
    ./TARGET_STM32F4/drivers/SDIO/: sdio_device.c sdio_device.h SDIOBlockDevice.cpp SDIOBlockDevice.h
  group TARGET_STM32F446xE
    ./TARGET_STM32F446xE/drivers/pin/: pin.cpp pin.h
  group thread
    ./thread/: timerInterrupt.cpp timerInterrupt.h
  group TMCStepper
    ./TMCStepper/: CHOPCONF.cpp COOLCONF.cpp DRV_STATUS.cpp GCONF.cpp IHOLD_IRUN.cpp PWMCONF.cpp TMC2208_bitfields.h TMC2208Stepper.cpp TMC2209_bitfields.h TMC2209Stepper.cpp TMC_MACROS.h TMCStepper.cpp TMCStepper.h
